# Keil uVision project lab7.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: STM32F401RBTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lab7 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Inc;.\src;.\RTE
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: main.c
    ./RTE/: startup_stm32f401xc.s system_stm32f4xx.c
    ./src/: misc.c stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_exti.c stm32f4xx_rcc.c stm32f4xx_gpio.c
software components: CMSIS:CORE 6.1.0
